# Keil uVision project can_scanner.uvprojx, settings and files
target Can_Device (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can_scanner
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\hdr;..\CAN_scanner
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group hdr
    ./hdr/: usart.h string_convertor.h dma.h device_init.h can.h can_lawicel.h watchdog.h tim.h
  group src
    ./src/: device_init.c usart.c string_convertor.c dma.c can.c can_lawicel.c watchdog.c tim.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
